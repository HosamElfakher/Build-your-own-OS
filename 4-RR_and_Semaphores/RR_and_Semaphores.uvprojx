# Keil uVision project RR_and_Semaphores.uvprojx, settings and files
target src (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Round_Robin_1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group OS
    ./: OS.c OS.h OS.s
  group System
    ./: SystemTick.c SystemTick.h
  group Global
    ./: tm4c123gh6pm.h
  group Application
    ./: APP.c
  group Semaphore
    ./: Semph.c Semph.h
  group list
    ./: list.c list.h
software components: Device:Startup 1.0.1
